<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\Composite_Example.ewp</path>
  </project>
  <batchBuild>
    <batchDefinition>
      <name>USB-Package-Composite_Example</name>
      <member>
        <project>Composite_Example</project>
        <configuration>STM3210B-EVAL</configuration>
      </member>
      <member>
        <project>Composite_Example</project>
        <configuration>STM3210C-EVAL</configuration>
      </member>
      <member>
        <project>Composite_Example</project>
        <configuration>STM3210E-EVAL</configuration>
      </member>
      <member>
        <project>Composite_Example</project>
        <configuration>STM3210E-EVAL_XL</configuration>
      </member>
      <member>
        <project>Composite_Example</project>
        <configuration>STM32L152-EVAL</configuration>
      </member>
    </batchDefinition>
  </batchBuild>
</workspace>


